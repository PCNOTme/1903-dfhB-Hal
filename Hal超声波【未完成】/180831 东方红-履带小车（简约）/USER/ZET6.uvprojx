# Keil uVision project ZET6.uvprojx, settings and files
target ZET6 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PWM +hex
  c flags: Optim=1 wLevel=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\HARDWARE\KEY;..\HARDWARE\TIMER;..\CORE;..\HARDWARE\TRIG;..\HARDWARE\TRIG;..\HARDWARE\ECHO;..\HARDWARE\ECHO;..\HARDWARE\TIMER;..\HARDWARE\ECHO;..\SYSTEM\usart;..\HARDWARE\MOTOR;..\HARDWARE\DUOJI;..\HARDWARE\CONTROL;..\HARDWARE\SHOW;..\HARDWARE\ENCODER;..\HARDWARE\DATA;..\HARDWARE\MPU6050;..\HARDWARE\MPU;..\HARDWARE\TIMER
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/ECHO/: echo.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/CONTROL/: control.c
    ../HARDWARE/SHOW/: DataScope_DP.C
    ../HARDWARE/MPU6050/: anbt_i2c.c anbt_dmp_mpu6050.c anbt_dmp_driver.c
    ../HARDWARE/DATA/: data.c
    ../HARDWARE/MPU/: turn.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group README
    ../: README.TXT
